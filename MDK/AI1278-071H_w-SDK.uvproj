# Keil uVision project AI1278-071H_w-SDK.uvproj, settings and files
target AI1278-071H (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: AI1278-071H +hex
  BeforeMake: cmd /C    del /F    AI1278-071H.hex
  AfterMake: cmd /C    copy /Y   Obj_1278-071\AI1278-071H.hex   .
  c define: USE_STDPERIPH_DRIVER STM32F072 USE_LORA_SX1278 PLATFORM=Bleeper
  c misc: --gnu
  c include: ..\Libraries\STM32F0xx_CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_CMSIS\Include;..\Libraries\STM32F0xx_CMSIS\RTOS;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\USER;..\Libraries\libshell;..\Libraries\Radio;..\USER\STM32F072RBx;..\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x14000
  memory RVCT9: RAM 0x200000c0 size 0x3f40
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group MDK_ARM
    ../Libraries/STM32F0xx_CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group USER
    ../USER/: cli.c board.c spi.c sx1276-Hal.c base64.c crc.c flash.c main.c xor_crypto.c uuid.c normalSlave.c normalMaster.c LinkListEvent.c gps.c bluetooth.c led.c button.c rtc.c sleep.c console_function.c RandomHopStartChannel.c UART_Console.c Console_Timer.c
    ../USER/STM32F072RBx/: stm32f0xx_it.c save_record.c system_stm32f0xx.c Base_Driver__UART2.c Base_Driver__UART1.c
  group libshell
    ../Libraries/libshell/: shell.c
  group AcSiP_Libraries
    ./AcSiP_Libries/: AI1278-071H__Protocol.lib AI1278-071H__Radio.lib
    ../Libraries/: Word_Queue.c Byte_Queue.c Message_Queue.c
