# Keil uVision project AI1278-401H_w-SDK.uvproj, settings and files
target AI1278-401H (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401CC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AI1278-401H +hex
  BeforeMake: cmd /C    del /F    AI1278-401H.hex
  AfterMake: cmd /C    copy /Y   Obj_1278-401\AI1278-401H.hex   .
  c define: USE_STDPERIPH_DRIVER STM32F401xx USE_STM32F401 USE_LORA_SX1278 PLATFORM=Bleeper
  c misc: --gnu
  c include: ..\Libraries\STM32F4xx_CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_CMSIS\Include;..\Libraries\STM32F4xx_CMSIS\RTOS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\Libraries\libshell;..\Libraries\Radio;..\USER\STM32F401VCx;..\Libraries\STM32F401_USB;..\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_flash_ramfunc.c
  group MDK_ARM
    ../Libraries/STM32F4xx_CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group USER
    ../USER/STM32F401VCx/: stm32f4xx_it.c usart1.c save_record.c tim9.c system_stm32f4xx.c Base_Driver__UART2.c Base_Driver__UART1.c Base_Driver__ADC1.c
    ../USER/: cli.c board.c spi.c sx1276-Hal.c base64.c crc.c flash.c main.c xor_crypto.c uuid.c normalSlave.c normalMaster.c LinkListEvent.c gps.c bluetooth.c led.c button.c usb_bsp.c usbd_cdc_vcp.c rtc.c sleep.c console_function.c RandomHopStartChannel.c UART_Console.c Console_Timer.c
    ../../: i2c1.c lis3dh_driver.c
  group libshell
    ../Libraries/libshell/: shell.c
  group STM32F401_USB
    ../Libraries/STM32F401_USB/: usbd_usr.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usb_core.c
  group AcSiP_Libraries
    ./AcSiP_Libries/: AI1278-401H__Protocol.lib AI1278-401H__Radio.lib
    ../Libraries/: Message_Queue.c Word_Queue.c Byte_Queue.c
